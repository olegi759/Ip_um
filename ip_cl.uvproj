# Keil uVision project ip_cl.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F330 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: ip_cl +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main_ipCL.c init_ipCL.c tpic_ipCL.c uart0_ipCL.c work_PC_ipCL.c timers_ipCL.c test_SL_ipCL.c DATAPAGE.ASM
